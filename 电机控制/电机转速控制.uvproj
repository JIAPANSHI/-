# Keil uVision project 电机转速控制.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 电机转速控制
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group c文件
    ./: main.c display.c key.c qudong.c
  group h文件
    ./: main.h qudong.h key.h display.h
